# Repository TransistorTun/Brightness-Meter

## KiCad design Brightness-Meter/Hardware/Test Board/Brightness_Meter_TB/Brightness_Meter_TB.kicad_pcb

Board: 2 copper layers, 74.3 x 91.5 mm, 87 parts (76 on the bottom side), 43 nets.

Parts:
3.3V1: RED; LED_D5.0mm
-5V_LED1: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 22uF/25V; CP_Elec_6.3x5.4
C2, C3: 10uF/16V; CAPMP3216X180N
C4, C11, C12, C13, C14, C16, C17, C19, C20, C22, C23, C24, C25, C26, C27: 100nF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C8, C9, C18, C21: 10uF/6.3V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 10pF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 1uF/16V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3: SS34; DIOM4325X250N
D2: ZMM3V3; ZDO_ZMM_3p5x1p45_STM
D4: ZMM5V1; ZDO_ZMM_3p5x1p45_STM
F1: Fuse_Small; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1: JACK-DC; SPARKFUN_PRT-12748
Q1, Q6: MMBT2222A; SOT23
Q2, Q3, Q4, Q5: BSN20; SOT23_NEX
R1, R2: 4.7k/1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R5, R6, R7, R8: R_Small_US; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: EVM-3ESX50B14; EVM-3ESX50B14_PAN
R9, R13, R31: EVM-3E; EVM-3ESX50B14_PAN
R10, R11: 0/1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: GL5528; R_LDR_5.0x4.1mm_P3mm_Vertical
R14: 220/1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R17, R18, R19, R20, R23, R24, R25, R26, R27, R28, R29, R30: 10k/1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R22, R32: 1k/1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: UP; SW_PUSH-12mm_Wuerth-430476085716
SW2: DOWN; SW_PUSH-12mm_Wuerth-430476085716
SW3: LEFT; SW_PUSH-12mm_Wuerth-430476085716
SW4: RIGHT; SW_PUSH-12mm_Wuerth-430476085716
SW5: SET; SW_PUSH-12mm_Wuerth-430476085716
SW6: MODE; SW_PUSH-12mm_Wuerth-430476085716
U1: ICL7662CPA; SOIC127P600X175-8N
U2: STM32F103C8T6; STM32F103C8T6_BP
U3: MCP6002; SOIC127P599X173-8N
U4: INA128; SOIC127P599X175-8N
U5: HX710B
U6: SSD1306
Vin_LED1: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
+3.3V: 3.3V1.2 (A), Q2.1 (G), Q3.1 (G), Q4.1 (G), Q5.1 (G), R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R23.1, R24.1, R27.1, R28.1, U2.1 (VBAT), U2.18 (3V3), U2.40 (3V3)
+5V: BZ1.1 (-), C1.1, C6.1, C8.1, C11.1, C13.1, C18.1, C19.1, C20.1, C21.1, D1.C, D3.C, D4.1, F1.2, R1.1, R3.2, R4.3, R14.2, R25.1, R26.1, R29.1, R30.1, U1.8 (V+), U2.38 (5V), U3.8 (VDD), U4.7 (V+), U5.7 (DVDD), U5.8 (AVDD), U6.1 (vcc)
-5V: -5V_LED1.1 (K), C3.2, C7.2, C9.2, C12.2, C14.2, U1.5 (VOUT), U3.4 (VSS), U4.4 (V-)
/Measure/CURRENT_SRC: C15.2, R5.1, R7.2, R9.2, R12.1, R31.2, U4.3 (+)
/Measure/vout: R10.2, R11.1, U4.6
ADC_CLK: Q4.2 (S), R27.2, U2.26 (PA9)
ADC_DATA: Q5.2 (S), R28.2, U2.25 (PA8)
ADC_HX71OB: C16.2, R11.2, U5.4 (INP)
ADC_INO: C4.1, C5.1, D2.1, R10.1, U2.5 (PA0)
BUZZER: R21.1, U2.27 (PA10)
CHANGE_RESISTOR: R32.2, U2.12 (PA7)
CLK_HX710B: Q4.3 (D), R29.2, U5.5 (PD_SCK)
DATA_HX710B: Q5.3 (D), R30.2, U5.6 (DOUT)
GND: C1.2, C3.1, C4.2, C5.2, C6.2, C7.1, C8.2, C9.1, C11.2, C12.1, C13.2, C14.1, C15.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, D1.A, D2.2, D4.2, J1.2, J1.3, Q1.2, Q6.2, R2.2, R4.1, R6.2, R9.1, R12.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.3 (GND), U1.6 (LV), U2.19 (GND), U2.20 (GND), U2.39 (GND), U4.2 (-), U5.2 (AGND), U6.2 (gnd), Vin_LED1.1 (K)
I2C_SCL: Q2.2 (S), R23.2, U2.34 (PB6)
I2C_SDA: Q3.2 (S), R24.2, U2.35 (PB7)
LED_INFO: R22.2, U2.24 (PB15)
unnamed: 3.3V1.1 (K), R22.1
unnamed: -5V_LED1.2 (A), R2.1
unnamed: BZ1.2 (+), D3.A, Q1.3
unnamed: F1.1, J1.1_1, J1.1_2
unnamed: Q1.1, R21.2
unnamed: Q6.1, R32.1
unnamed: Q6.3, R31.1
unnamed: R13.1, U4.8 (Rg)
unnamed: R13.2, U4.1 (Rg)
unnamed: C2.1, U1.2 (CAP+)
unnamed: C2.2, U1.4 (CAP-)
unnamed: R3.1, R5.2, U3.3 (VINA+)
unnamed: C10.1, R6.1, R8.2, U3.2 (VINA-)
unnamed: R4.2, U3.5 (VINB+)
unnamed: C10.2, R7.1, R8.1, U3.1 (VOUTA)
unnamed: C17.2, R14.1, U5.1 (VREF)
unnamed: R1.2, Vin_LED1.2 (A)
SCL_SSD1306: Q2.3 (D), R25.2, U6.3 (scl)
SDA_SSD1306: Q3.3 (D), R26.2, U6.4 (sda)
SW_DOWN: C23.2, R16.1, SW2.2, U2.8 (PA3)
SW_LEFT: C24.2, R17.1, SW3.2, U2.6 (PA1)
SW_MODE: C27.2, R20.1, SW6.2, U2.7 (PA2)
SW_RIGHT: C25.2, R18.1, SW4.2, U2.10 (PA5)
SW_SET: C26.2, R19.1, SW5.2, U2.11 (PA6)
SW_UP: C22.2, R15.1, SW1.2, U2.9 (PA4)
VREF: C16.1, U3.6 (VINB-), U3.7 (VOUTB), U4.5 (Ref), U5.3 (INN)

## KiCad design Brightness-Meter/Hardware/Brightness_Meter/Brightness_Meter.kicad_pcb

Board: 2 copper layers, 78.9 x 82.0 mm, 153 parts (16 on the bottom side), 67 nets.

Parts:
3.3V: 3.3V; TestPoint_Pad_D1.5mm
3.3V#2, 5V#2: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
5V: 5V; TestPoint_Pad_D1.5mm
-5V: -5V; TestPoint_Pad_D1.5mm
-5V#2: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2, C6, C7: 10uF/16V; CAPMP3216X180N
C3, C26, C31, C32, C33, C51: 10uF/16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 22uF/25V; CP_Elec_6.3x5.4
C5, C8: 1uF/25V; CAPMP3216X180N
C9, C10: 4.7uF/25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C12, C25: 10nF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13: 1nF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 47pF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 0.1uF/16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C17: 47uF/6.3V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C20, C22: 4.7uF/10V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C21, C23, C34, C35, C36, C37, C44, C45, C46, C47, C48, C49, C50, C52: 100nF/16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24, C39: 1uF/16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C28, C29, C30: 20pF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C38: 10pF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C40, C41, C43, C54: 100nF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C53: 10uF/6.3V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: SS34; DIOM4325X250N
D4: ZMM3V3; ZDO_ZMM_3p5x1p45_STM
D6: Led_test; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DOWN1: DOWN; SW_TL3300CF260Q
F1: Fuse_Small; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
GND: GND; TestPoint_Pad_D1.5mm
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J1: JACK-DC; SPARKFUN_PRT-12748
J2: Load Program; PinHeader_1x04_P2.54mm_Vertical
L1: 6.8uH/2.2A; IND_SDE0604A_5P8X5P2X4P5_BRN
LED1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
LEFT1: LEFT; SW_TL3300CF260Q
MODE1: MODE; SW_TL3300CF260Q
Q1, Q6, Q7: MMBT2222A; SOT23
Q2, Q3, Q4, Q5: BSN20; SOT23_NEX
R1, R2, R25, R26: 0/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R9, R10, R16, R30, R31, R32, R33, R34, R35, R39, R40, R41, R42, R43, R44: 10k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7, R8: R_Small_US; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 330k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 47k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 30k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 2.49k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 49.9k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R20, R36, R37, R45, R46: 1k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R27: 4.7k/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21: EVM-3ESX50B14; EVM-3ESX50B14_PAN
R22, R23, R28, R38: EVM-3E; EVM-3ESX50B14_PAN
R24: GL5528; R_LDR_5.0x4.1mm_P3mm_Vertical
R29: 220/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RG_1, RG_2: RG; TestPoint_Pad_D1.5mm
RIGHT1: RIGHT; SW_TL3300CF260Q
RP_1, RP_2: RP; TestPoint_Pad_D1.5mm
Reset: SW_Push; SW_SPST_B3U-1000P
SET1: SET; SW_TL3300CF260Q
U1: STM32F030C8Tx; LQFP-48_7x7mm_P0.5mm
U2: ICL7662CPA; SOIC127P600X175-8N
U3: MCP6002; SOIC127P599X173-8N
U4: INA128; SOIC127P599X175-8N
U5: SSD1306
U6: LM1117DT-3.3; TO-252-3_TabPin2
U7: TPS54331D; SOIC127P599X175-8N
U8: HX710B
UP1: UP; SW_TL3300CF260Q
V_Ref: V_Ref; TestPoint_Pad_D1.5mm
V_out: V_out; TestPoint_Pad_D1.5mm
Vin: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Vin#2: Vin; TestPoint_Pad_D1.5mm
Y1: 8MHz; Crystal_SMD_EuroQuartz_MQ-4Pin_7.0x5.0mm
Y2: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: 3.3V.1, C7.1, C8.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, Q2.1 (G), Q3.1 (G), Q4.1 (G), Q5.1 (G), R2.1, R3.1, R9.1, R10.1, R18.1, R20.1, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R41.1, R42.1, U1.1 (VDD), U1.9 (VDDA), U1.24 (VDD), U1.48 (VDD), U6.2 (VO)
+5V: 5V.1, BZ1.1 (-), C3.1, C5.1, C6.1, C16.1, C17.1, C26.1, C31.1, C34.1, C35.1, C42.1, C43.1, C53.1, C54.1, D3.C, J2.1, L1.1, R6.2, R14.1, R17.1, R21.3, R29.2, R39.1, R40.1, R43.1, R44.1, U2.8 (V+), U3.8 (VDD), U4.7 (V+), U5.1 (vcc), U6.3 (VI), U8.7 (DVDD), U8.8 (AVDD)
-5V: -5V.1, -5V#2.1 (K), C2.2, C32.2, C33.2, C36.2, C37.2, U2.5 (VOUT), U3.4 (VSS), U4.4 (V-)
/MCU/BOOT0: R1.1, R2.2, U1.44 (BOOT0)
/MCU/LED_TEST: D6.1 (K), U1.2 (PC13)
/MCU/OSC32_IN: C30.1, U1.3 (PC14), Y2.1
/MCU/OSC32_OUT: C29.1, U1.4 (PC15), Y2.2
/MCU/OSC_IN: C28.1, U1.5 (PF0), Y1.1
/MCU/OSC_OUT: C27.1, U1.6 (PF1), Y1.3
/MCU/RESET: C50.2, R3.2, Reset.2, U1.7 (NRST)
/MCU/SWCLK: J2.3, U1.37 (PA14)
/MCU/SWDIO: J2.2, U1.34 (PA13)
/Power/Vin: C4.1, C9.1, C10.1, C11.1, D1.C, F1.2, R11.1, R19.1, U7.2 (VIN), Vin#2.1
/measure/CURRENT_SRC: C39.2, R7.1, R8.2, R23.2, R24.1, R28.2, RP_1.1, U4.3 (+)
/measure/vout: R25.2, R26.1, U4.6, V_out.1
ADC_CLK: Q4.2 (S), R41.2, U1.31 (PA10)
ADC_DATA: Q5.2 (S), R42.2, U1.30 (PA9)
ADC_HX71OB: C40.2, R26.2, U8.4 (INP)
ADC_INO: C51.1, C52.1, D4.1, R25.1, U1.10 (PA0)
BUZZER: R37.1, U1.20 (PB2)
CHANGE_GAIN: R46.2, U1.32 (PA11)
CHANGE_RESISTOR: R45.2, U1.33 (PA12)
CLK_HX710B: Q4.3 (D), R43.2, U8.5 (PD_SCK)
DATA_HX710B: Q5.3 (D), R44.2, U8.6 (DOUT)
GND: 3.3V#2.1 (K), 5V#2.1 (K), C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.2, C35.2, C36.1, C37.1, C39.1, C41.1, C42.2, C43.2, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.2, C52.2, C53.2, C54.2, D1.A, D2.A, D4.2, DOWN1.1, DOWN1.2, GND.1, J1.2, J1.3, J2.4, LED1.2 (A), LEFT1.1, LEFT1.2, MODE1.1, MODE1.2, Q1.2, Q6.2, R1.2, R4.2, R12.2, R13.2, R16.2, R21.1, R23.1, R24.2, R27.2, RIGHT1.1, RIGHT1.2, RP_2.1, Reset.1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
I2C_SCL: Q2.2 (S), R9.2, U1.42 (PB6)
I2C_SDA: Q3.2 (S), R10.2, U1.43 (PB7)
LED_INFO: R36.2, U1.19 (PB1)
unnamed: 3.3V#2.2 (A), R18.2
unnamed: 5V#2.2 (A), R17.2
unnamed: -5V#2.2 (A), R27.1
unnamed: BZ1.2 (+), D3.A, Q1.3
unnamed: C13.2, R13.1
unnamed: D6.2 (A), R20.2
unnamed: F1.1, J1.1_1, J1.1_2
unnamed: LED1.1 (K), R36.1
unnamed: Q1.1, R37.2
unnamed: Q6.1, R45.1
unnamed: Q6.3, R28.1
unnamed: Q7.1, R46.1
unnamed: Q7.2, R22.1, RG_2.1, U4.8 (Rg)
unnamed: Q7.3, R38.1
unnamed: R14.2, R15.1
unnamed: R22.2, R38.2, RG_1.1, U4.1 (Rg)
unnamed: C1.1, U2.2 (CAP+)
unnamed: C1.2, U2.4 (CAP-)
unnamed: R6.1, R7.2, U3.3 (VINA+)
unnamed: C38.1, R4.1, R5.2, U3.2 (VINA-)
unnamed: R21.2, U3.5 (VINB+)
unnamed: C38.2, R5.1, R8.1, U3.1 (VOUTA)
unnamed: C15.2, U7.1 (BOOT)
unnamed: C13.1, C14.1, U7.6 (COMP)
unnamed: R11.2, R12.1, U7.3 (EN)
unnamed: C15.1, D2.C, L1.2, U7.8 (PH)
unnamed: C12.1, U7.4 (SS)
unnamed: R15.2, R16.1, U7.5 (VSENSE)
unnamed: C41.2, R29.1, U8.1 (VREF)
unnamed: R19.2, Vin.2 (A)
SCL_SSD1306: Q2.3 (D), R39.2, U5.3 (scl)
SDA_SSD1306: Q3.3 (D), R40.2, U5.4 (sda)
SW_DOWN: C45.2, DOWN1.3, DOWN1.4, R31.1, U1.46 (PB9)
SW_LEFT: C46.2, LEFT1.3, LEFT1.4, R32.1, U1.26 (PB13)
SW_MODE: C49.2, MODE1.3, MODE1.4, R35.1, U1.21 (PB10)
SW_RIGHT: C47.2, R33.1, RIGHT1.3, RIGHT1.4, U1.45 (PB8)
SW_SET: C48.2, R34.1, SET1.3, SET1.4, U1.25 (PB12)
SW_UP: C44.2, R30.1, U1.22 (PB11), UP1.3, UP1.4
VREF: C40.1, U3.6 (VINB-), U3.7 (VOUTB), U4.5 (Ref), U8.3 (INN), V_Ref.1
